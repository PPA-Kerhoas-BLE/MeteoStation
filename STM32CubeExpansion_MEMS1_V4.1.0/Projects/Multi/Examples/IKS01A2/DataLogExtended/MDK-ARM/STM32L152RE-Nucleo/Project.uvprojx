# Keil uVision project Project.uvprojx, settings and files
target STM32L1xx_Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: STM32L152xE USE_STM32L1XX_NUCLEO USE_HAL_DRIVER
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Src
    ../../Src/: com.c DemoSerial.c main.c cube_hal_l1.c stm32l1xx_hal_msp.c stm32l1xx_it.c serial_protocol.c sensor_commands.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c
  group Example/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xe.s
