# Keil uVision project Project.uvprojx, settings and files
target STM32L0xx-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ../../Src/: com.c cube_hal_l0.c DemoSerial.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c serial_protocol.c sensor_commands.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
